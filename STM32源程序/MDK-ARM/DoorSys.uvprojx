# Keil uVision project DoorSys.uvprojx, settings and files
target DoorSys (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DoorSys +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Source\App\Inc;..\Source\Dal\Inc;..\Source\Hal\Inc;..\Source\App\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group APP
    ../Source/App/Src/: eeprom_readwrite.c key_control.c led_blink.c task.c usart2_rs485.c SysDoorStatus.c rc522.c DataAnalysis.c history_record.c rtc_time.c face_app.c onenet_app.c
    ../Source/App/OLED/: oled.c
  group Dal
    ../Source/Dal/Src/: dal_key.c dal_led.c dal_usart2.c CRC16.c eeprom.c Dal_relay.c dal_spi.c dal_1302.c dal_ble.c dal_face.c dal_esp8266.c
  group Hal
    ../Source/Hal/Src/: hal_key.c hal_relay.c hal_led.c hal_system.c hal_usart2.c hal_iic.c hal_spi.c hal_1302.c hal_ble.c hal_face.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_usart.c stm32f1xx_ll_spi.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_ll_exti.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_spi.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_wwdg.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
